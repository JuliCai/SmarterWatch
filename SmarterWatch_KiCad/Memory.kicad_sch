File: SmarterWatch_KiCad/Memory.kicad_sch (KiCad schematic)
At the start: 7 parts, among them U15 M24C64-WMN6TP

Commit message: FINAL
Parts:
- U12, U13, U14: value ~ -> (none)
